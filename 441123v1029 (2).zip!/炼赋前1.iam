# Autodesk Inventor assembly: 조립품1
## iProperties
Created: 2014-11
Part Number: 조립품1
Document SubType Name: Assembly
Designer: elite
Author: elite
